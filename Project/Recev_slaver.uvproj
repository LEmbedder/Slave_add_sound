# Keil uVision project Recev_slaver.uvproj, settings and files
target SLAVER (ARM-ADS)
  device: STM32F105RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Recevslaver +hex
  AfterMake: fromelf.exe --bin -o ..\Output\Recevslaver.bin ..\Output\Recevslaver.axf
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,MS_SLAVE,_RECEV_
  c misc: --c99
  c include: ..\API;..\APP;..\CMOS;..\Driver;..\FWLib\inc;..\FWLib\src;..\Project;..\CMSIS;..\Driver\audio
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartCode
    ../CMSIS/Startup/: startup_stm32f10x_hd.s
    ./: main.c stm32f10x_it.c
    ../CMOS/: asm.s
  group APP
    ../APP/: xiaomu.c hardware.c USART.c
  group API
    ../API/: Display.c File.c nRF.c g-sensor.c SLAVERAPIS2.c GEngineCfg.c Config.c IAP.c hdr.c
  group Driver
    ../Driver/: DAC.c NRF24L01.c lcd.c Flash.c Motor.c MMA7660FC.c sentence.c Battery.c SingleWireSlave.c OneLine.c recev.c GD62429.c
  group FWLib
    ../FWLib/src/: stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_rcc.c misc.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_dac.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_iwdg.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_crc.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group CMOS
    ../CMOS/: CMLIB.c CMOS.c
  group audio
    ../Driver/audio/: audio.c chanel.c decode.c mix.c pcm.c adpcm.c
